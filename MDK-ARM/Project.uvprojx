# Keil uVision project Project.uvprojx, settings and files
target STM32L152RC (32L152C-DISCOVERY) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: STM32L-Discovery +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32L1XX_MDP
  c include: ..\;..\inc;..\..\..\libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32L-DISCOVERY;..\..\..\libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s startup_stm32l1xx_hd.s
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_wwdg.c misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group User
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
    ../src/: system_stm32l1xx.c stm32l1xx_it.c main.c
  group Doc
    ../: Readme.txt
target STM32L152RB (STM32L-DISCOVERY) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L-Discovery
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32L1XX_MD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3c00
  memory RVCT10: RAM 0x20003c00 size 0x400
